Commit message: increased obejct

File: robotino_gazebo_worlds/objects/simple_blue_box2.urdf (robot description, URDF)
Before this commit: robot simple_blue_box2, 1 links, 0 joints
Links:
- link simple_blue_box2: geometry collision box size=0.3 0.3 0.3; visual box size=0.3 0.3 0.3
